SRCBRANCH = "main"
SRC_REPO = "git@github.com/roclub/connector-v2-kernel.git;protocol=ssh"
SRCREV = "AUTOINC"
KBRANCH = "${SRCBRANCH}"

KBUILD_DEFCONFIG = "p3767_antmicro_job_defconfig"
